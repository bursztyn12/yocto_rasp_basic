FILESEXTRAPATHS_prepend := "${THISDIR}:"
SRC_URI += "file://0001-add-uart2-dts.patch"

